# IAR project STM32G474_FKLibrary.ewp, settings and files
configuration STM32G474_FKLibrary (ARM, debug)
  General.OGChipSelectEditMenu: STM32G474RE ST STM32G474RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G474xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32G4xx_HAL_Driver/Inc; ../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32G4xx/Include; ../Drivers/CMSIS/Include; ../Module
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32G474_FKLibrary.hex
  ILINK.IlinkOutputFile: STM32G474_FKLibrary.out
  ILINK.IlinkIcfFile: stm32g474xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Inc/: main.h
    ../Core/Src/: main.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Application/User/Module/CRC
    ../Module/CRC/drv_src/: crc_drv.c crc_drv.h
    ../Module/CRC/c_src/: crc_glb_vars.c crc_glb_vars.h crc_idef.h crc_init.c crc_init.h crc_task.c crc_task.h
    ../Module/CRC/: crc_udef.h
  group Application/User/Module/FK
    ../Module/FK/: fk_adc_udef.h fk_dac_udef.h fk_dma_udef.h fk_flash_udef.h fk_gpio_udef.h fk_i2c_udef.h fk_nvic_udef.h fk_power_udef.h fk_rtc_udef.h fk_spi_udef.h fk_system_udef.h fk_timer_udef.h fk_uart_udef.h fk_udef.h fk_watch_dog_udef.h
    ../Module/FK/drv_src/: fk_drv.c fk_drv.h
    ../Module/FK/c_src/: fk_glb_vars.c fk_glb_vars.h fk_idef.h fk_init.c fk_init.h fk_task.c fk_task.h
  group Application/User/Module/HBTC
    ../Module/HBTC/drv_src/: hbtc_drv.c hbtc_drv.h
    ../Module/HBTC/c_src/: hbtc_glb_vars.c hbtc_glb_vars.h hbtc_idef.h hbtc_init.c hbtc_init.h hbtc_task.c hbtc_task.h
    ../Module/HBTC/: hbtc_udef.h
  group Application/User/Module/MODBUS_SLAVE
    ../Module/MODBUS_SLAVE/drv_src/: modbus_slave_drv.c modbus_slave_drv.h
    ../Module/MODBUS_SLAVE/c_src/: modbus_slave_glb_vars.c modbus_slave_idef.h modbus_slave_init.c modbus_slave_init.h modbus_slave_task.c modbus_slave_task.h
    ../Module/modbus_slave/c_src/: modbus_slave_glb_vars.h
    ../Module/modbus_slave/: modbus_slave_udef.h
  group Application/User/Module/PFC
    ../Module/PFC/drv_src/: pfc_drv.c pfc_drv.h
    ../Module/PFC/c_src/: pfc_glb_vars.c pfc_glb_vars.h pfc_idef.h pfc_init.c pfc_init.h pfc_task.c pfc_task.h
    ../Module/PFC/: pfc_udef.c pfc_udef.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_cortex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
